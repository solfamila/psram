# IAR project pdm_sai_multi_channel_tdm_edma_cm33_core0.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT798S_M33_0 NXP MIMXRT798S_M33_0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT798SGFOA_cm33_core0; BOOT_HEADER_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_MULTI_ADAPTERS=1; CODEC_CS42448_ENABLE
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../../flash_config; ../../../../../../../CMSIS/Core/Include; ../../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../../devices/MIMXRT798S; ../../../../../../../devices/MIMXRT798S/periph; ../../../../../../../devices/MIMXRT798S/drivers; ../../../../../../../devices/MIMXRT798S/utilities/debug_console_lite; ../../../../../../../devices/MIMXRT798S/utilities/str; ../../../../../../../components/codec/i2c; ../../../../../../../components/codec; ../../../../../../../components/codec/port; ../../../../../../../components/codec/port/cs42448; ../../../../../../../components/codec/cs42448; ../../../../../../../components/i2c; ../../../../../../../components/uart
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT798SGFOA_cm33_core0
  AARM.AUserIncludes: ..; ../../../../../flash_config; ../../../../../../../CMSIS/Core/Include; ../../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../../devices/MIMXRT798S; ../../../../../../../devices/MIMXRT798S/periph; ../../../../../../../devices/periph; ../../../../../../../devices/MIMXRT798S/drivers; ../../../../../../../devices/MIMXRT798S/utilities/debug_console_lite; ../../../../../../../devices/MIMXRT798S/utilities/str; ../../../../../../../components/codec/i2c; ../../../../../../../components/codec; ../../../../../../../components/codec/port; ../../../../../../../components/codec/port/cs42448; ../../../../../../../components/codec/cs42448; ../../../../../../../components/i2c; ../../../../../../../components/uart
  OBJCOPY.OOCOutputFile: pdm_sai_multi_channel_tdm_edma.bin
  ILINK.IlinkOutputFile: pdm_sai_multi_channel_tdm_edma_cm33_core0.out
  ILINK.IlinkIcfFile: MIMXRT798Sxxxx_cm33_core0_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: MIMXRT798Sxxxx_cm33_core0_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT798SGFOA_cm33_core0; BOOT_HEADER_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_MULTI_ADAPTERS=1; CODEC_CS42448_ENABLE
  ICCARM.CCOptLevel: 3
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT798Sxxxx_cm33_core0_flash.icf
  group source
    ../: pdm_sai_multi_channel_tdm_edma.c mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group flash_config
    ../../../../../flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group device
    ../../../../../../../devices/MIMXRT798S/: fsl_device_registers.h MIMXRT798S_cm33_core0.h MIMXRT798S_cm33_core0_COMMON.h MIMXRT798S_cm33_core0_features.h system_MIMXRT798S_cm33_core0.c system_MIMXRT798S_cm33_core0.h
  group device/periph
    ../../../../../../../devices/MIMXRT798S/periph/: PERI_ADC.h PERI_AHBSC0.h PERI_AHBSC3.h PERI_AHBSC4.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CDOG.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CLKCTL2.h PERI_CLKCTL3.h PERI_CLKCTL4.h PERI_CMP.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUG_MAILBOX.h PERI_DMA.h PERI_ELS.h PERI_FLEXIO.h PERI_FREQME.h PERI_FRO.h PERI_GDET.h PERI_GLIKEY.h PERI_GPIO.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX0.h PERI_INPUTMUX1.h PERI_IOPCTL0.h PERI_IOPCTL1.h PERI_IOPCTL2.h PERI_ITRC.h PERI_JPEGDEC.h PERI_JPGDECWRP.h PERI_LCDIF.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_LP_FLEXCOMM.h PERI_MIPI_DSI_HOST.h PERI_MMU.h PERI_MRT.h PERI_MU.h PERI_NIC.h PERI_OCOTP.h PERI_OSC32KNP.h PERI_OSCCA.h PERI_OSTIMER.h PERI_PDM.h PERI_PINT.h PERI_PKC.h PERI_PMC.h PERI_PNGDEC.h PERI_PUF.h PERI_PVTS.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RSTCTL2.h PERI_RSTCTL3.h PERI_RSTCTL4.h PERI_RTC.h PERI_SCT.h PERI_SDADC.h PERI_SEMA42.h PERI_SLEEPCON0.h PERI_SLEEPCON1.h PERI_SYSCON0.h PERI_SYSCON1.h PERI_SYSCON2.h PERI_SYSCON3.h PERI_SYSCON4.h PERI_SYSPM.h PERI_TRNG.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_WWDT.h PERI_XCACHE.h PERI_XSPI.h
  group startup/iar
    ../../../../../../../devices/MIMXRT798S/iar/: startup_MIMXRT798S_cm33_core0.s
  group drivers
    ../../../../../../../devices/MIMXRT798S/drivers/: fsl_clock.c fsl_clock.h fsl_edma_soc.c fsl_edma_soc.h fsl_iopctl.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_edma.h fsl_edma_core.h fsl_edma.c fsl_glikey.h fsl_glikey.c fsl_gpio.h fsl_gpio.c fsl_lpflexcomm.h fsl_lpflexcomm.c fsl_lpuart.h fsl_lpuart.c fsl_lpi2c.h fsl_lpi2c.c fsl_pdm_edma.h fsl_pdm_edma.c fsl_pdm.h fsl_pdm.c fsl_sai_edma.h fsl_sai_edma.c fsl_sai.h fsl_sai.c fsl_xspi.c fsl_xspi.h
  group utilities
    ../../../../../../../devices/MIMXRT798S/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../../../devices/MIMXRT798S/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../../devices/MIMXRT798S/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group codec
    ../../../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
    ../../../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../../../components/codec/cs42448/: fsl_cs42448.h fsl_cs42448.c
  group codec/port
    ../../../../../../../components/codec/port/: fsl_codec_adapter.c fsl_codec_adapter.h
  group codec/port/cs42448
    ../../../../../../../components/codec/port/cs42448/: fsl_codec_cs42448_adapter.h fsl_codec_cs42448_adapter.c
  group component/i2c
    ../../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
