# IAR project fxls8974cf_motion_wakeup_cm33_core0.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT798S_M33_0 NXP MIMXRT798S_M33_0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT798SGFOA_cm33_core0; BOOT_HEADER_ENABLE=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../../../../mimxrt700evk/flash_config; ../../../../../../../../CMSIS/Core/Include; ../../../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../../../CMSIS/Driver/Include; ../../../../../../../../devices/MIMXRT798S; ../../../../../../../../devices/MIMXRT798S/periph; ../../../../../../../../devices/MIMXRT798S/template; ../../../../../../../../devices/MIMXRT798S/drivers; ../../../../../../../../devices/MIMXRT798S/cmsis_drivers; ../../../../../../../../devices/MIMXRT798S/utilities; ../../../../../../../../components/lists; ../../../../../../../../devices/MIMXRT798S/utilities/str; ../../../../../../../../devices/MIMXRT798S/utilities/debug_console; ../../../../../../../../components/serial_manager; ../../../../../../../../components/uart; ../../../../../../../../middleware/issdk/sensors; ../../../../../../../../middleware/issdk/drivers/systick; ../../../../../../../../middleware/issdk/drivers/gpio/i.mx/i.mxrt700; ../../../../../../../../middleware/issdk/drivers/gpio
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT798SGFOA_cm33_core0
  AARM.AUserIncludes: ..; ../../../../../../../mimxrt700evk/flash_config; ../../../../../../../../CMSIS/Core/Include; ../../../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../../../CMSIS/Driver/Include; ../../../../../../../../devices/MIMXRT798S; ../../../../../../../../devices/MIMXRT798S/periph; ../../../../../../../../devices/periph; ../../../../../../../../devices/MIMXRT798S/template; ../../../../../../../../devices/MIMXRT798S/drivers; ../../../../../../../../devices/MIMXRT798S/cmsis_drivers; ../../../../../../../../devices/MIMXRT798S/utilities; ../../../../../../../../components/lists; ../../../../../../../../devices/MIMXRT798S/utilities/str; ../../../../../../../../devices/MIMXRT798S/utilities/debug_console; ../../../../../../../../components/serial_manager; ../../../../../../../../components/uart; ../../../../../../../../middleware/issdk/sensors; ../../../../../../../../middleware/issdk/drivers/systick; ../../../../../../../../middleware/issdk/drivers/gpio/i.mx/i.mxrt700; ../../../../../../../../middleware/issdk/drivers/gpio
  OBJCOPY.OOCOutputFile: fxls8974cf_motion_wakeup.bin
  ILINK.IlinkOutputFile: fxls8974cf_motion_wakeup_cm33_core0.out
  ILINK.IlinkIcfFile: MIMXRT798Sxxxx_cm33_core0_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: MIMXRT798Sxxxx_cm33_core0_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT798SGFOA_cm33_core0; BOOT_HEADER_ENABLE=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT798Sxxxx_cm33_core0_flash.icf
  group source
    ../: fxls8974cf_motion_wakeup.c mimxrt700evk.h RTE_Device.h issdk_hal.h frdm_stbi_a8974_shield.h mimxrt700evk.c fsl_debug_console_conf.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h
  group flash_config
    ../../../../../../../mimxrt700evk/flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group CMSIS_driver/Include
    ../../../../../../../../CMSIS/Driver/Include/: Driver_USART.h Driver_Common.h Driver_I2C.h Driver_Common.h Driver_SPI.h Driver_Common.h
  group device
    ../../../../../../../../devices/MIMXRT798S/: fsl_device_registers.h MIMXRT798S_cm33_core0.h MIMXRT798S_cm33_core0_COMMON.h MIMXRT798S_cm33_core0_features.h system_MIMXRT798S_cm33_core0.c system_MIMXRT798S_cm33_core0.h
  group device/periph
    ../../../../../../../../devices/MIMXRT798S/periph/: PERI_ADC.h PERI_AHBSC0.h PERI_AHBSC3.h PERI_AHBSC4.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CDOG.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CLKCTL2.h PERI_CLKCTL3.h PERI_CLKCTL4.h PERI_CMP.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUG_MAILBOX.h PERI_DMA.h PERI_ELS.h PERI_FLEXIO.h PERI_FREQME.h PERI_FRO.h PERI_GDET.h PERI_GLIKEY.h PERI_GPIO.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX0.h PERI_INPUTMUX1.h PERI_IOPCTL0.h PERI_IOPCTL1.h PERI_IOPCTL2.h PERI_ITRC.h PERI_JPEGDEC.h PERI_JPGDECWRP.h PERI_LCDIF.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_LP_FLEXCOMM.h PERI_MIPI_DSI_HOST.h PERI_MMU.h PERI_MRT.h PERI_MU.h PERI_NIC.h PERI_OCOTP.h PERI_OSC32KNP.h PERI_OSCCA.h PERI_OSTIMER.h PERI_PDM.h PERI_PINT.h PERI_PKC.h PERI_PMC.h PERI_PNGDEC.h PERI_PUF.h PERI_PVTS.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RSTCTL2.h PERI_RSTCTL3.h PERI_RSTCTL4.h PERI_RTC.h PERI_SCT.h PERI_SDADC.h PERI_SEMA42.h PERI_SLEEPCON0.h PERI_SLEEPCON1.h PERI_SYSCON0.h PERI_SYSCON1.h PERI_SYSCON2.h PERI_SYSCON3.h PERI_SYSCON4.h PERI_SYSPM.h PERI_TRNG.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_WWDT.h PERI_XCACHE.h PERI_XSPI.h
  group startup/iar
    ../../../../../../../../devices/MIMXRT798S/iar/: startup_MIMXRT798S_cm33_core0.s
  group drivers
    ../../../../../../../../devices/MIMXRT798S/drivers/: fsl_clock.c fsl_clock.h fsl_edma_soc.c fsl_edma_soc.h fsl_iopctl.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_edma.h fsl_edma_core.h fsl_edma.c fsl_glikey.h fsl_glikey.c fsl_gpio.h fsl_gpio.c fsl_lpflexcomm.h fsl_lpflexcomm.c fsl_lpuart.h fsl_lpuart.c fsl_lpuart_edma.h fsl_lpuart_edma.c fsl_lpspi.h fsl_lpspi.c fsl_lpspi_edma.h fsl_lpspi_edma.c fsl_lpi2c.h fsl_lpi2c.c fsl_lpi2c_edma.h fsl_lpi2c_edma.c fsl_xspi.c fsl_xspi.h
    ../../../../../../../../devices/MIMXRT798S/cmsis_drivers/: fsl_lpuart_cmsis.h fsl_lpuart_cmsis.c fsl_lpi2c_cmsis.h fsl_lpi2c_cmsis.c fsl_lpspi_cmsis.h fsl_lpspi_cmsis.c
  group utilities
    ../../../../../../../../devices/MIMXRT798S/utilities/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../../../../devices/MIMXRT798S/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console
    ../../../../../../../../devices/MIMXRT798S/utilities/debug_console/: fsl_debug_console.h fsl_debug_console.c
  group component/lists
    ../../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/serial_manager
    ../../../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/uart
    ../../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group issdk/sensors
    ../../../../../../../../middleware/issdk/sensors/: register_io_i2c.c register_io_spi.c sensor_io_spi.c sensor_io_i2c.c register_io_i2c.h register_io_spi.h sensor_io_spi.h sensor_io_i2c.h sensor_drv.h fxls8974.h fxls8974_drv.h fxls8974_drv.c
  group issdk/drivers/systick
    ../../../../../../../../middleware/issdk/drivers/systick/: systick_utils.c systick_utils.h
  group issdk/drivers/gpio
    ../../../../../../../../middleware/issdk/drivers/gpio/: Driver_GPIO.h
  group issdk/drivers/gpio/i.mx/i.mxrt700
    ../../../../../../../../middleware/issdk/drivers/gpio/i.mx/i.mxrt700/: gpio_driver.c gpio_driver.h
  group doc
    ../: readme.md examples_shared_readme.md
